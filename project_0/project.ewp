# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G474xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\nogcc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\libraries\STM32G4xx_HAL\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\STM32G4xx_HAL\CMSIS\Include; applications; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\libc\compilers\common; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\HAL_Drivers; ..\libraries\STM32G4xx_HAL\STM32G4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: STM32G431xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c dataqueue.c pipe.c ringbuffer.c completion.c workqueue.c ringblk_buf.c
  group Drivers
    board/CubeMX_Config/Src/: stm32g4xx_hal_msp.c
    ../libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/iar/: startup_stm32g474xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: device.c clock.c mempool.c thread.c mem.c components.c object.c ipc.c irq.c timer.c idle.c scheduler.c kservice.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32G4xx_HAL/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_dma.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_crc.c stm32g4xx_hal_cryp_ex.c
    ../libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
